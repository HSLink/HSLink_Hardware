# Repository HSLink/HSLink_Hardware

File README.md:

# HSLink_Hardware
用于存放历史HSLink的硬件工程。

## Release Note:

### v1.0

* 初版

### v1.2.0

* 修改了WS2812管脚，与串口控制脚交换，以使用SPI
* 使用负载开关替换替换mos来控制对外输出

### v1.2.1

* 更换负载开关以提高smt良率

### v1.3.1

* 修改外观适配外壳
* 使用sepic替换buck以避免输入5v时输出达不到5v
* 依旧使用mos控制tvcc输出
* 修复下载时可能出现的串口乱码
* 添加io失能串口输出

## 内嵌字体下载

[MiSans](https://hyperos.mi.com/font/download)

## KiCad design HSLinkCompact_v1.3.1/HSLinkPro.kicad_pcb

File HSLinkCompact_v1.3.1/README.md:

# HSLinkPro

适配鹿小班等外壳。

## KiCAD 版本

使用9.0以上版本的KiCAD打开。

## 制作指南

[制作指南](./ProductionGuide.md)

Parts:
C35: 0.1u; C_0402_1005Metric
C55: 10u; C_0603_1608Metric
C58: 100u/16V; CP_Elec_6.3x7.7
C62, C63, C69, C70: 1u; C_0402_1005Metric
C71: 4.7u; C_0402_1005Metric
F1: 2A; Fuse_0805_2012Metric
J1: IDC 2x10p 夹板; IDC-Header_2x10_P2.54mm_Horizontal
J2: USB_C_Receptacle_USB2.0; USB_C_Receptacle_G-Switch_GT-USB-7010ASV
Q3, Q6, Q7: AO3401; SOT-23
Q4, Q8: SS8050; SOT-23
R14, R15: 5.1k; R_0402_1005Metric
R29: 100k; R_0402_1005Metric
R36, R38: 2k; R_0402_1005Metric
R39: 100K; R_0402_1005Metric
TP1, TP2, TP3, TP4: TestPoint; ScrewHole_1.25mm_2mm
TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13: TestPoint; TestPoint_Pad_D1.0mm
U7: CH213K; SOT-23-3; Manufacturer Part CH213K; LCSC Part Name CH213K
U15, U16, U17, U18: ESD0524P; DFN2510-10_L2.5-W1.0-P0.50-BL

Connections:
+3V3: TP7.1; also elsewhere on the board
+5V: C35.1, C55.1, C58.1, C62.1, F1.2, TP10.1, U7.3 (VI+); also elsewhere on the board
+5V_OUT: C63.1, J1.19, U7.2 (VO-)
/<NO NET>: J1.5, U16.5, U16.6; also elsewhere on the board
/Logic Translation/TVCC: Q3.3 (D), TP9.1; also elsewhere on the board
/MCU/BOOT0: TP13.1; also elsewhere on the board
/MCU/BOOT1: TP12.1; also elsewhere on the board
/MCU/WS2812: TP8.1; also elsewhere on the board
/PORT_EN: R36.1; also elsewhere on the board
/P_EN: R38.1; also elsewhere on the board
/Power/TRANS_VREF: TP6.1; also elsewhere on the board
/SRST: J1.15, U17.5, U17.6; also elsewhere on the board
/SWCLK/TCK: J1.9, U17.2, U17.9; also elsewhere on the board
/SWDIO/TMS: J1.7, U17.1, U17.10; also elsewhere on the board
/TDO: J1.13, U17.4, U17.7; also elsewhere on the board
/TRST: J1.3, U16.4, U16.7; also elsewhere on the board
/UART_DTR: J1.14, U18.1, U18.10; also elsewhere on the board
/UART_RTS: J1.16, U18.2, U18.9; also elsewhere on the board
/UART_RX: J1.20, U18.5, U18.6; also elsewhere on the board
/UART_TX: J1.18, U18.4, U18.7; also elsewhere on the board
/USB_D+: J2.A6 (D+), J2.B6 (D+), U15.4, U15.7; also elsewhere on the board
/USB_D-: J2.A7 (D-), J2.B7 (D-), U15.2, U15.9; also elsewhere on the board
/VREF: J1.1, U16.2, U16.9; also elsewhere on the board
GND: C35.2, C55.2, C58.2, C62.2, C63.2, C69.2, C70.2, C71.2, J1.4, J1.6, J1.8, J1.10, J1.12, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), Q4.2 (E), Q8.2 (E), R14.2, R15.2, TP1.1, TP2.1, TP3.1, TP4.1, TP11.1, U7.1 (GND), U15.3, U15.8, U16.3, U16.8, U17.3, U17.8, U18.3, U18.8; also elsewhere on the board
unnamed: J2.A5 (CC1), R14.1
unnamed: J2.B5 (CC2), R15.1
unnamed: Q3.1 (G), Q4.3 (C), R29.2
unnamed: Q4.1 (B), R36.2
unnamed: Q6.1 (G), Q7.1 (G), Q8.3 (C), R39.1
unnamed: Q6.2 (S), Q7.2 (S), R39.2
unnamed: Q8.1 (B), R38.2
TRANS_VCC: C69.1, Q3.2 (S), Q6.3 (D), R29.1, TP5.1; also elsewhere on the board
TVCC_OUT: C70.1, C71.1, J1.2, Q7.3 (D), U16.1, U16.10; also elsewhere on the board
VUSB: F1.1, J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), U15.1, U15.5, U15.6, U15.10

Notes on the sheet:
C41410190
C70158
MCU would control it when vref is higher than 1.6 or configed as out

Parts:
C21, C22: 15p; C_0402_1005Metric
C23, C57: 0.1u; C_0402_1005Metric
D1: WS2812B; LED_WS2812B-Mini_PLCC4_3.5x3.5mm
D5: SS24; D_SOD-123
J3: Header 1.27 4P; PinHeader_1x04_P1.27mm_Vertical; not fitted
R1, R17, R18: 10k; R_0402_1005Metric
R2, R9, R10, R11, R12, R21: 100k; R_0402_1005Metric
R22, R23: 22R; R_0402_1005Metric
SW1: 1TS028A-1900-0600-CT; SW_Push_1P1T_NO_Vertical_Wuerth_434133025816
U1: HPM5301IEG1; QFN-48-1EP_6x6mm_P0.4mm_EP4.2x4.2mm
Y1: 24M; Crystal_SMD_2016-4Pin_2.0x1.6mm

Connections:
+3V3: J3.1, R1.1, SW1.2; also elsewhere on the board
+5V: C57.1, D5.2 (A); also elsewhere on the board
/MCU/ADC_TVCC: R11.2, R12.1, U1.26 (PB09/TMR0.CAPT1/URT2.RXD/I2C2.SDA/SPI2.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)
/MCU/ADC_VREF: R9.2, R10.1, U1.27 (PB08/TMR0.COMP1/URT2.TXD/I2C2.SCL/SPI2.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)
/MCU/BOOT0: R17.1, U1.8 (PA02/TMR1.COMP1/URT0.DE/URT0.RTS/I2C0.S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); also elsewhere on the board
/MCU/BOOT1: R18.1, SW1.1, U1.7 (PA03/TMR1.CAPT1/URT0.CTS/I2C0.SDA/SPI3.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); also elsewhere on the board
/MCU/ISP_RX: J3.3, U1.11 (PA01/TMR1.CAPT0/URT0.RXD/TRGM0.P01/ACMP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)
/MCU/ISP_TX: J3.2, U1.12 (PA00/TMR1.COMP0/URT0.TXD/TRGM0.P00)
/MCU/NRST: C23.1, R1.2, U1.13 (~RESETN)
/MCU/SPI_CS: U1.25 (PB10/TMR0.COMP2/URT2.DE/URT2.RTS/SPI2.C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), U1.42 (PA26/SPI1.CS0/XPI0.CA_D3/TRGM0.P02)
/MCU/SRST: U1.20 (PB15/TMR0.COMP3/URT3.TXD/SPI2.DAT3/TRGM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); also elsewhere on the board
/MCU/SWCLK/TCK: U1.24 (PB11/URT2.CTS/SPI2.SCLK/ACMP.COMP1/ADC0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), U1.41 (PA27/SPI1.SCLK/XPI0.CA_SCLK/TRGM0.P03); also elsewhere on the board
/MCU/SWDIO_DIR: U1.38 (PA30/SPI1.DAT2/XPI0.CA_D1/TRGM0.P06/USB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); also elsewhere on the board
/MCU/SWDIO/TMS: R22.1, R23.1; also elsewhere on the board
/MCU/TDI: U1.22 (PB13/TMR1.COMP3/URT3.DE/URT3.RTS/I2C3.S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); also elsewhere on the board
/MCU/TDO: U1.23 (PB12/URT3.CTS/I2C3.SDA/SPI2.MISO/TRGM0.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); also elsewhere on the board
/MCU/TRANS_PWM: U1.4 (PA10/TMR0.COMP2/URT2.DE/URT2.RTS/SPI3.C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); also elsewhere on the board
/MCU/TRST: U1.21 (PB14/URT3.RXD/SPI2.DAT2/TRGM0.P02/ADC0.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); also elsewhere on the board
/MCU/UART_DTR: U1.47 (PA06/TMR0.CAPT0/URT1.RXD/I2C1.SDA/SPI0.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); also elsewhere on the board
/MCU/UART_EN#: U1.1 (PA04/URT1.CTS/SPI0.CS0/TRGM0.P04/JTAG.T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); also elsewhere on the board
/MCU/UART_RTS: U1.48 (PA05/TMR1.COMP2/URT1.DE/URT1.RTS/SPI0.S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); also elsewhere on the board
/MCU/UART_RX: U1.3 (PA09/TMR0.CAPT1/URT2.RXD/I2C2.SDA/SPI3.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); also elsewhere on the board
/MCU/UART_TX: U1.2 (PA08/TMR0.COMP1/URT2.TXD/I2C2.SCL/SPI3.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); also elsewhere on the board
/MCU/WS2812: D1.4 (DIN), U1.46 (PA07/TMR0.COMP0/URT1.TXD/I2C1.SCL/SPI0.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); also elsewhere on the board
/MCU/XIN: C21.1, U1.35 (XTALI), Y1.1
/MCU/XOUT: C22.1, U1.36 (XTALO), Y1.3
/PORT_EN: R2.1, U1.37 (PA31/SPI1.DAT3/XPI0.CA_CS0/TRGM0.P07/US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); also elsewhere on the board
/P_EN: R21.1, U1.19 (PY00/URT0.TXD/USB0.ID/PMIC_PY00/PURT.TX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); also elsewhere on the board
/USB_D+: U1.44 (PA24/I2C2.SCL/SPI1.CS2/XPI0.CA_CS1/TRGM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); also elsewhere on the board
/USB_D-: U1.43 (PA25/I2C2.SDA/SPI1.CS1/XPI0.CA_DQS/TRGM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); also elsewhere on the board
/VREF: R9.1; also elsewhere on the board
GND: C21.2, C22.2, C23.2, C57.2, D1.3 (VSS), J3.4, R2.2, R10.2, R12.2, R17.2, R18.2, R21.2, Y1.2, Y1.4; also elsewhere on the board
unnamed: D1.1 (VDD), D5.1 (K)
unnamed: R22.2, U1.40 (PA28/I2C3.SDA/SPI1.MISO/XPI0.CA_D0/TRGM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)
unnamed: R23.2, U1.39 (PA29/I2C3.SCL/SPI1.MOSI/XPI0.CA_D2/TRGM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)
TVCC_OUT: R11.1; also elsewhere on the board

Parts:
C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C36, C37, C38, C39, C42, C43, C44, C45: 0.1u; C_0402_1005Metric
Q2, Q5: SS8050; SOT-23
R16: 10k; R_0402_1005Metric
R24, R25, R26, R27: 22R; R_0402_1005Metric
R28, R30, R31, R32, R33, R40: 100R; R_0402_1005Metric
R34: 100k; R_0402_1005Metric
R35, R37: 2k; R_0402_1005Metric
U2, U3, U4, U5, U6, U8, U9, U11, U12: SN74LVC1T45DCK; SOT-363_SC-70-6

Connections:
+3V3: C24.2, C26.2, C28.2, C30.2, C32.2, C36.2, C38.2, C42.2, C44.2, R16.2, U2.1 (VCCA), U2.5 (DIR), U3.1 (VCCA), U4.1 (VCCA), U5.1 (VCCA), U5.5 (DIR), U6.1 (VCCA), U6.5 (DIR), U8.1 (VCCA), U9.1 (VCCA), U11.1 (VCCA), U12.1 (VCCA); also elsewhere on the board
/<NO NET>: R27.2; also elsewhere on the board
/Logic Translation/TVCC: C25.1, C27.1, C29.1, C31.1, C33.1, C37.1, C39.1, C43.1, C45.1, R34.2, U2.6 (VCCB), U3.6 (VCCB), U4.6 (VCCB), U5.6 (VCCB), U6.6 (VCCB), U8.6 (VCCB), U9.6 (VCCB), U11.6 (VCCB), U12.6 (VCCB); also elsewhere on the board
/Logic Translation/UART_EN: Q2.3 (C), R16.1, U8.5 (DIR), U11.5 (DIR), U12.5 (DIR)
/MCU/SRST: R37.1; also elsewhere on the board
/MCU/SWCLK/TCK: U2.3 (A); also elsewhere on the board
/MCU/SWDIO_DIR: U3.5 (DIR); also elsewhere on the board
/MCU/SWDIO/TMS: U3.3 (A); also elsewhere on the board
/MCU/TDI: U5.3 (A); also elsewhere on the board
/MCU/TDO: U4.3 (A); also elsewhere on the board
/MCU/TRST: U6.3 (A); also elsewhere on the board
/MCU/UART_DTR: U11.3 (A); also elsewhere on the board
/MCU/UART_EN#: R35.1; also elsewhere on the board
/MCU/UART_RTS: U12.3 (A); also elsewhere on the board
/MCU/UART_RX: U9.3 (A); also elsewhere on the board
/MCU/UART_TX: U8.3 (A); also elsewhere on the board
/SRST: R40.2; also elsewhere on the board
/SWCLK/TCK: R24.2; also elsewhere on the board
/SWDIO/TMS: R25.2; also elsewhere on the board
/TDO: R26.2; also elsewhere on the board
/TRST: R28.2; also elsewhere on the board
/UART_DTR: R32.2; also elsewhere on the board
/UART_RTS: R33.2; also elsewhere on the board
/UART_RX: R31.2; also elsewhere on the board
/UART_TX: R30.2; also elsewhere on the board
GND: C24.1, C25.2, C26.1, C27.2, C28.1, C29.2, C30.1, C31.2, C32.1, C33.2, C36.1, C37.2, C38.1, C39.2, C42.1, C43.2, C44.1, C45.2, Q2.2 (E), Q5.2 (E), U2.2 (GND), U3.2 (GND), U4.2 (GND), U4.5 (DIR), U5.2 (GND), U6.2 (GND), U8.2 (GND), U9.2 (GND), U9.5 (DIR), U11.2 (GND), U12.2 (GND); also elsewhere on the board
unnamed: Q2.1 (B), R35.2
unnamed: Q5.1 (B), R37.2
unnamed: Q5.3 (C), R40.1
unnamed: R24.1, U2.4 (B)
unnamed: R25.1, U3.4 (B)
unnamed: R26.1, U4.4 (B)
unnamed: R27.1, U5.4 (B)
unnamed: R28.1, U6.4 (B)
unnamed: R30.1, U8.4 (B)
unnamed: R31.1, R34.1, U9.4 (B)
unnamed: R32.1, U11.4 (B)
unnamed: R33.1, U12.4 (B)

Parts:
C1, C3, C5, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C53, C56, C59, C66: 0.1u; C_0402_1005Metric
C2, C6, C60, C64, C67: 4.7u; C_0402_1005Metric
C4, C9, C51: 10u; C_0603_1608Metric
C7, C8: 22u; C_0603_1608Metric
C48, C49: 1u; C_0402_1005Metric
C50: 6.8p; C_0402_1005Metric
C52, C54: 1n; C_0402_1005Metric
C65: 1uF; C_0402_1005Metric
C68: 220nF; C_0402_1005Metric
D4: SS24; D_SOD-123
L3, L4, L5: 10uH; L_Murata_DFE201610P
R4: 47k; R_0402_1005Metric
R5: 20k; R_0402_1005Metric
R6: 15k; R_0402_1005Metric
R7: 88.7k; R_0402_1005Metric
R8, R19: 150k; R_0402_1005Metric
R13: 100k; R_0402_1005Metric
R20: 0R; R_0402_1005Metric
U1: HPM5301IEG1; QFN-48-1EP_6x6mm_P0.4mm_EP4.2x4.2mm
U10: ME6211A33; SOT-23
U13: LMV321; SOT-23-5
U14: SGM6607AYTN6G/TR; TSOT-23-6; Manufacturer Part SGM6607AYTN6G/TR; LCSC Part Name 1.2A高电压升压转换器

Connections:
+3V3: C4.1, C5.1, C11.1, C12.1, C13.1, C14.1, C15.1, C49.1, C51.1, C59.1, U1.6 (VIO_B00), U1.16 (VPMC), U1.29 (VIO_B01), U1.31 (VREFH), U1.32 (VANA), U1.34 (VIO_B00), U10.2 (VO); also elsewhere on the board
+5V: C48.1, C53.1, C56.1, C64.1, L3.1, U10.3 (VI), U13.5 (V+), U14.1 (VIN); also elsewhere on the board
/MCU/TRANS_PWM: R7.1, R13.2; also elsewhere on the board
/Power/TRANS_FB: C50.2, R4.2, R5.1, R6.1, U14.6 (FB)
/Power/TRANS_VREF: C52.2, R5.2, R19.1, U13.3 (-), U13.4; also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C48.2, C49.2, C51.2, C53.2, C54.2, C56.2, C59.2, C60.2, C64.2, C66.2, C67.2, C68.2, L4.2, R6.2, R13.1, U1.30 (VREFL), U1.49 (VSS), U10.1 (GND), U13.2 (V-), U14.4 (GND); also elsewhere on the board
unnamed: C52.1, R7.2, R8.1
unnamed: C68.1, R20.2
unnamed: C65.2, D4.2 (A), L4.1
unnamed: L5.2, U1.15 (DCDC_LP)
unnamed: C3.1, C6.1, U1.10 (VDD_OTPCAP)
unnamed: C1.1, C2.1, U1.17 (VDD_PMCCAP)
unnamed: C54.1, R8.2, U13.1 (+)
unnamed: R20.1, U14.5 (COMP)
unnamed: C60.1, R19.2, U14.2 (EN)
unnamed: C65.1, L3.2, U14.3 (SW)
TRANS_VCC: C50.1, C66.1, C67.1, D4.1 (K), R4.1; also elsewhere on the board
VDD_SOC: C7.1, C8.1, C9.1, C10.1, C16.1, C17.1, C18.1, C19.1, C20.1, L5.1, U1.5 (VDD_SOC), U1.9 (VDD_SOC), U1.28 (VDD_SOC), U1.33 (VDD_SOC), U1.45 (VDD_SOC)

Notes on the sheet:
节点电流法 VFB/R6=(TVREF-VFB)/R5+(TVCC-VFB)/R4
from sympy import symbols, Eq, solve, collect, expand VFB, VREF, TVCC, TVREF, R4, R5, R6 = symbols('VFB VREF TVCC TVREF R4 R5 R6') eq = Eq(VFB / R6, (VREF - VFB) / R5 + (TVCC - VFB) / R4) sol = solve(eq, VREF)[0] sol_collected = collect(expand(sol), TVCC) values = { VFB: 1.229, R6: 15e3, R5: 20e3, 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
1.229V
TVREF = 3.39064539007092 - 0.425531914893617*TVCC TVREF = 2.6247 V → TVCC = 1.80 V TVREF = 1.9864 V → TVCC = 3.30 V TVREF = 1.2630 V → TVCC = 5.00 V

Board: 4 copper layers, 44.0 x 44.0 mm, 154 parts (9 on the bottom side), 83 nets.

## Commit log

2025-03-08 readme
2025-03-08 v1.0
2025-03-17 v1.0 pdf
2025-03-23 v1.2.1
2025-03-23 v1.2.0
2025-03-23 1.2.0 1.2.1 release note
2025-04-12 v1.3.1
2025-04-12 降低工艺需求
2025-04-21 fix: 1.2.1 修复UART RX未上拉问题
2025-05-15 add: v1.3.1 production guide
2025-05-23 add: v1.3.1 panel
